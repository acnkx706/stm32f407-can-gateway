# Keil uVision project F407ZG.uvprojx, settings and files
target F407ZG (5060960::V5.06 update 7 (build 960)::ARM_Compiler_5.06u7)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: F407ZG +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,LV_CONF_INCLUDE_SIMPLE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Drivers\User\Inc;..\Drivers\lvgl;..\Drivers\lvgl\src;..\Drivers\wiznet\Ethernet;..\Drivers\wiznet\Ethernet\W5500;..\Drivers\wiznet\Internet\httpServer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/User
    ../Drivers/User/Src/: led.c key.c usart.c lcd_fonts.c lcd_image.c lcd_spi_154.c can_gw.c w5500_port.c net_tcp.c modbus_tcp.c web_srv.c lv_port.c
    ../Drivers/wiznet/Ethernet/W5500/: w5500.c
    ../Drivers/wiznet/Ethernet/: wizchip_conf.c socket.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group LVGL
    ../Drivers/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev_scroll.c lv_indev.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style_gen.c lv_obj_style.c lv_obj_tree.c lv_obj.c lv_refr.c lv_theme.c
    ../Drivers/lvgl/src/draw/: lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_draw.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Drivers/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../Drivers/lvgl/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_draw_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp.c
    ../Drivers/lvgl/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_draw_vglite.c lv_vglite_buf.c lv_vglite_utils.c
    ../Drivers/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../Drivers/lvgl/src/draw/sdl/: lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c lv_draw_sdl.c
    ../Drivers/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../Drivers/lvgl/src/draw/sw/: lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c lv_draw_sw.c
    ../Drivers/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../Drivers/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Drivers/lvgl/src/misc/: lv_anim_timeline.c lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style_gen.c lv_style.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt_ap.c lv_txt.c lv_utils.c
    ../Drivers/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../Drivers/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Drivers/lvgl/src/extra/: lv_extra.c
    ../Drivers/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Drivers/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Drivers/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Drivers/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Drivers/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Drivers/lvgl/src/extra/widgets/calendar/: lv_calendar_header_arrow.c lv_calendar_header_dropdown.c lv_calendar.c
    ../Drivers/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Drivers/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Drivers/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Drivers/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Drivers/lvgl/src/extra/widgets/led/: lv_led.c
    ../Drivers/lvgl/src/extra/widgets/list/: lv_list.c
    ../Drivers/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Drivers/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Drivers/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Drivers/lvgl/src/extra/widgets/span/: lv_span.c
    ../Drivers/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Drivers/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Drivers/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Drivers/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Drivers/lvgl/src/extra/widgets/win/: lv_win.c
    ../Drivers/lvgl/src/font/: lv_font.c lv_font_fmt_txt.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_20.c lv_font_montserrat_24.c lv_font_montserrat_28.c
software components: CMSIS:CORE 5.5.0
